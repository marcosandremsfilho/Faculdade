	EXPORT __main
	AREA	EXAMPLE5_14, CODE, READONLY
__main
	LDR	R1, =VALOR_1
	LDR	R2, =VALOR_2
	LDR	R3, =RESULT
	
	LDRSB R4, [R1]	; R4 = +96
	LDRSB R5, [R2]
	
	CMP R4,R5
	BEQ __main
	CMP R4, R5
	BGT MULTIPLICA
	CMP R4, R5
	BLT DELAY
	
DELAY
	PUSH { R0 }
	LDR R0 , =0x00000002
 L1
	SUBS R0 , R0 ,#1 ; R0 =R0 -1
	BNE L1
	POP { R0 }
	BX LR
	
MULTIPLICA
	SMULL R7, R6, R4, R5
HL	B	HL

VALOR_1 	DCB 	+96
VALOR_2 	DCB 	+70
	ALIGN
	END